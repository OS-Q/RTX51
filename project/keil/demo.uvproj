# Keil uVision project demo.uvproj, settings and files
target demo (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: demo +hex
  c flags: Optimize=8 SizeSpeed=1
  group ABS_TASK
    ../src/ABS_TASK/: absTask.c
  group TASK
    ../src/TASK/: task.c setup.c mode.c
  group OS
    ../src/RTOS/: Conf_tny.A51
  group ALGORITHM
    ../src/ALGORITHM/PID/: PID.c
    ../src/ALGORITHM/FILTER/: FILTER.C
  group COMMON_SOFTWARE
    ../src/COMMON_SOFTWARE/DATA_SCOPE/: DataScope_DP.c
    ../src/COMMON_SOFTWARE/STORAGE/: storage.c
  group DEVICES
    ../HARDWARE/DEVICES/BUTTON/: BUTTON.C
    ../HARDWARE/DEVICES/LED/: LED.c
    ../HARDWARE/DEVICES/MOTOR/DC_MOTOR/: MOTOR.C
    ../HARDWARE/DEVICES/MOTOR/SERVO/: SERVO.C
    ../HARDWARE/DEVICES/MOTOR/STEP_MOTOR/: STEP_MOTOR.C
    ../HARDWARE/DEVICES/COMMON_DEVICES/RELAY/: RELAY.C
    ../HARDWARE/DEVICES/SENSOR/ANGLE/: ANGLE.C
    ../HARDWARE/DEVICES/DISPLAY/1602/: LCD1602.c
    ../HARDWARE/DEVICES/COMMON_DEVICES/74H/: 74HC595.C
  group COMMON_HARDWARE
    ../HARDWARE/COMMON_HARDWARE/: fixedPulser.c
  group BSP
    ../HARDWARE/BSP/: ADC.c delay.c GPIO.c PCA.c stc15_pwm.c timer.c USART1.C stc15_eeprom.c
